# Keil uVision project 停车位接收端与上位机通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 停车位接收端与上位机通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\12864;..\Delay;..\Main;..\NRF24L01;..\Usart;..\OLED
  group Main
    ../Main/: main.c
  group Usart
    ../Usart/: Usart.c Usart.h
  group NRF24L01
    ../NRF24L01/: NRF2401.c NRF2401.h
  group 12864
    ../12864/: 12864.c 12864.h
  group Delay
    ../Delay/: delay.c delay.h
  group OLED
    ../OLED/: oled.c oled.h oledfont.h
