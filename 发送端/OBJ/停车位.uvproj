# Keil uVision project 停车位.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 停车位 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\AD;..\MAIN;..\DELAY;..\Usart;..\NRF24L01
  group Main
    ../MAIN/: main.c
  group AD
    ../AD/: AD.C AD.H
  group Delay
    ../DELAY/: Delay.c Delay.h
  group Usart
    ../Usart/: Usart.c Usart.h
  group nrf24l01
    ../NRF24L01/: nrf2401.c nrf2401.h
